IMAGE_INSTALL:append = "	\
    optee-test			\
"
